File: v1.0/plate/plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 375 x 125 mm, 0 parts

Commit message: plate done
Other:
- outline, holes or cut-outs redrawn
